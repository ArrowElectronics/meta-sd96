PACKAGECONFIG_append = " http2 ssl"

