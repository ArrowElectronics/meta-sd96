FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-dt-overlay-sd96.patch"

COMPATIBLE_MACHINE = 'sama5d27-sd96'

