FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-u-boot-sd96.patch"

COMPATIBLE_MACHINE = 'sama5d27-sd96'

